# Autodesk Inventor assembly: Assembly1
## iProperties
Created: 2018-06
Part Number: Assembly1
Document SubType Name: Assembly
Designer: M.Shelton
Author: M.Shelton
